# Repository robber5/Flying5

## EAGLE design hardware/Flying5 v1.0 - schematic design/Flying5.brd

Parts:
C1: 10uF; EIA3216
C2, C6: 0.1uF; 0402-CAP
C10: 2.2nF; 0402-CAP
C14: 10nF; 0402-CAP
ESP12E: ESP12ESMD; ESP12E-SMD
FTDI: FTDI_DEVICE; FTDI_DEVICE_SIDE
J1: 短接点; 1X02
JP3: Front Right; 1X02_LONGPADS
JP4: Rear Right; 1X02_LONGPADS
JP5: Rear Left; 1X02_LONGPADS
JP6: Front Left; 1X02_LONGPADS
MOTOR1, MOTOR2, MOTOR3, MOTOR4: IRLML2502; SOT23
POWER: M02PTH; 1X02
R1, R7, R9, R11, R13: 1K; 0402-RES
R4, R5, R8, R10, R12, R14: 10K; 0402-RES
S1: SWITCH-SPDT-SMD-A; SWITCH-SPST-SMD-A
U2: MIC5205; SOT23-5
U$1: MPU-6050-1; QFN-24-4MM2

Connections:
3.3V: C1.A (+), C2.1, ESP12E.CH_PD, ESP12E.VCC, R4.1, R5.1, U2.5 (OUT), U$1.13 (VDD)
CTS: FTDI.P$5 (CTS)
DTR: ESP12E.RESET, FTDI.P$1 (DTR)
GND: C1.C (-), C2.2, C6.1, C10.1, C14.1, ESP12E.GND, FTDI.P$6 (GND), J1.1, MOTOR1.2 (S), MOTOR2.2 (S), MOTOR3.2 (S), MOTOR4.2 (S), POWER.1, R1.1, R8.2, R10.1, R12.1, R14.1, U2.2 (GND), U$1.1 (CLKIN), U$1.11 (FSYNC), U$1.18 (GND)
GPIO0: ESP12E.GPIO0, J1.2
M1: ESP12E.GPIO5, R7.1, R8.1
M2: ESP12E.GPIO4, R9.1, R10.2
M3: ESP12E.GPIO13, R11.1, R12.2
M4: ESP12E.GPIO14, R13.1, R14.2
unnamed: JP3.2, MOTOR4.3 (D)
unnamed: C14.2, U$1.8 (VLOGIC)
unnamed: POWER.2, S1.2
unnamed: JP4.2, MOTOR3.3 (D)
unnamed: JP5.2, MOTOR2.3 (D)
unnamed: JP6.2, MOTOR1.3 (D)
unnamed: ESP12E.GPIO15, R1.2
unnamed: C6.2, U$1.10 (REGOUT)
unnamed: C10.2, U$1.20 (CPOUT)
unnamed: MOTOR1.1 (G), R7.2
unnamed: MOTOR2.1 (G), R9.2
unnamed: MOTOR3.1 (G), R11.2
unnamed: MOTOR4.1 (G), R13.2
RX: ESP12E.RXD0 (RX), FTDI.P$3 (RXI)
SCL: ESP12E.GPIO12, R4.2, U$1.23 (SCL)
SDA: ESP12E.GPIO2, R5.2, U$1.24 (SDA)
TX: ESP12E.TXD0 (TX), FTDI.P$2 (TXO)
VCC: ESP12E.ADC, FTDI.P$4 (VCC), JP3.1, JP4.1, JP5.1, JP6.1, S1.1 (O), U2.1 (IN), U2.3 (EN)

Notes on the sheet:
发动机
传感器

Board: 2 copper layers, 83.2 x 83.2 mm, 31 parts (1 on the bottom side), 26 nets.

## Commit log

2015-09-18 base update
2016-04-12 change to esp8266
2016-04-12 new commit.
2016-04-15 20160415
2016-06-21 add switch
2016-06-22 更改目录结构
2016-07-12 pcb update
2016-09-13 update sch
2016-09-13 update pcb
2016-09-22 gen gerber

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
